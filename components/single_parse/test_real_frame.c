#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "single_parse.h"

// 实际的帧数据
static const uint8_t real_frame[] = {
    0xDA, 0xDA, 0x01, 0x7B, 0xFA, 0x0A, 0x20, 0x20, 0x22, 0x63, 0x6D, 0x64, 0x22, 0x3A, 0x20, 0x22,
    0x77, 0x69, 0x66, 0x69, 0x5F, 0x63, 0x6F, 0x6E, 0x6E, 0x65, 0x63, 0x74, 0x22, 0x2C, 0xFA, 0x0A,
    0x20, 0x20, 0x22, 0x70, 0x61, 0x72, 0x61, 0x6D, 0x73, 0x22, 0x3A, 0x20, 0x7B, 0xFA, 0x0A, 0x20,
    0x20, 0x20, 0x20, 0x22, 0x73, 0x73, 0x69, 0x64, 0x22, 0x3A, 0x20, 0x22, 0x6C, 0x75, 0x6E, 0x61,
    0x77, 0x61, 0x6B, 0x65, 0x22, 0x2C, 0xFA, 0x0A, 0x20, 0x20, 0x20, 0x20, 0x22, 0x70, 0x61, 0x73,
    0x73, 0x77, 0x6F, 0x72, 0x64, 0x22, 0x3A, 0x20, 0x22, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 0x37,
    0x38, 0x22, 0xFA, 0x0A, 0x20, 0x20, 0x7D, 0xFA, 0x0A, 0x7D, 0x52, 0x13, 0x0A, 0x0A
};

// 期望的解码数据（前几个字节）
static const uint8_t expected_data_start[] = {0x01, 0x7B, 0x0A};

int main(void) {
    printf("Testing real frame parsing...\n");
    
    single_parse_handle_t parser = single_parse_new(1024);
    if (!parser) {
        printf("FAIL: Failed to create parser\n");
        return 1;
    }
    
    size_t out_len = 0;
    const uint8_t* out_buf = NULL;
    
    // 逐字节解析
    for (size_t i = 0; i < sizeof(real_frame); i++) {
        out_buf = single_parse_unpack(parser, real_frame[i], &out_len);
        if (out_len > 0) {
            printf("SUCCESS: Frame parsed, length: %zu\n", out_len);
            printf("First 3 bytes: %02X %02X %02X\n", 
                   out_buf[0], out_buf[1], out_buf[2]);
            
            // 验证前几个字节
            if (out_len >= 3 && memcmp(out_buf, expected_data_start, 3) == 0) {
                printf("PASS: Data matches expected start\n");
                single_parse_free(parser);
                return 0;
            } else {
                printf("FAIL: Data does not match expected start\n");
                single_parse_free(parser);
                return 1;
            }
        }
    }
    
    printf("FAIL: Frame not parsed (out_len = %zu)\n", out_len);
    single_parse_free(parser);
    return 1;
}
